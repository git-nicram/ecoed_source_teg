# IAR project base_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\include; ..\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: base_project.bin
  ILINK.IlinkOutputFile: base_project.out
  ILINK.IlinkIcfFile: D:\DEV\DEV\base_project\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group CMSIS
    ../source/: startup_efm32gg.s system_efm32gg.c
  group source
    ../: main.c
